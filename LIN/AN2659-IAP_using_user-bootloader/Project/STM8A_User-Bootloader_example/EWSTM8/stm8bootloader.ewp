# IAR project stm8bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 1
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\includes
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: stm8bootloader.out
  ILINK.IlinkIcfFile: lnkstm8s208mb.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: main.h stm8a_conf.h stm8a_macro.h stm8a_map.h stm8a_type.h
  group Source Files
    ../src/: main.c MAIN.SRC
