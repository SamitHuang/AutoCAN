# IAR project stm8bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\includes
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8bootloader.hex
  ILINK.IlinkOutputFile: stm8bootloader.out
  ILINK.IlinkIcfFile: lnkstm8l152c6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: main.h stm8l15x.h stm8l15x_conf.h
  group Source Files
    ../src/: main.c
    ./: stm8l15x_interrupt.s
